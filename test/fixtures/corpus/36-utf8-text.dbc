VERSION "1"

NS_ :

BS_:

BU_: A B

BO_ 100 Temp: 8 A
 SG_ Outside : 0|8@1+ (1,-40) [-40|215] "°C" B

CM_ SG_ 100 Outside "Température Ünicöde – 温度";
